<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PBL4_W6.ewp</path>
  </project>
  <batchBuild />
</workspace>
